## folded/tpkit/panel/Kconfig
```kconfig
#
# huawei touchscreen driver configuration
#


source "drivers/devkit/tpkit/panel/st/Kconfig"
```
